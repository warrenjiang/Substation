# Keil uVision project Eth_freertos.uvprojx, settings and files
target Eth_Freertos (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: D:\Keil5\ARM\ARMCC\bin\fromelf.exe --bin -o  ./output/@L.bin  ./output/@L.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\User;..\Lib3.5.0;..\Lib3.5.0\inc;..\Lib3.5.0\CoreSupport;..\Lib3.5.0\Eth_Driver\inc;..\FreeRTOSV8.1.2\include;..\FreeRTOSV8.1.2\portable\RVDS\ARM_CM3;..\Lwip-1.4.1\src\include;..\Lwip-1.4.1\src\include\lwip;..\Lwip-1.4.1\src\include\ipv4;..\Lwip-1.4.1\src\include\netif;..\Lwip-1.4.1\port\STM32F107;..\Lwip-1.4.1\port\STM32F107\FreeRTOS;..\Bsp;..\CANOpen\inc;..\CANOpen\inc\stm32;..\User\canopen;..\MQTT
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMISS
    ../Lib3.5.0/CoreSupport/: core_cm3.c
    ../Lib3.5.0/startup/arm/: startup_stm32f10x_cl.s
    ../Lib3.5.0/: system_stm32f10x.c
  group USER
    ../User/: main.h lwipopts.h FreeRTOSConfig.h main.c netconfig.c netinit.c stm32f10x_it.c tcp_client.c app_flash.c app_Plat.c app_ntp.c
    ../User/canopen/: TestMaster.c
  group STM32F10x_StdPeriph_Driver
    ../Lib3.5.0/src/: misc.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_flash.c
    ../Lib3.5.0/Eth_Driver/src/: stm32_eth.c
  group FreeRTOS/Source
    ../FreeRTOSV8.1.2/: list.c queue.c tasks.c
    ../FreeRTOSV8.1.2/portable/MemMang/: heap_4.c
    ../FreeRTOSV8.1.2/portable/RVDS/ARM_CM3/: port.c
  group Lwip1.4.1/User
    ../Lwip-1.4.1/port/STM32F107/FreeRTOS/: ethernetif.c sys_arch.c
  group Lwip1.4.1
    ../Lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../Lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../Lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Lwip-1.4.1/src/netif/: etharp.c
  group Bsp
    ../Bsp/: bsp.c bsp_can.c bsp_cpu_flash.c bsp_timer.c bsp_usart.c bsp_mqtt_ota.c bsp_led.c bsp_iwdg.c
  group CANOpen/src
    ../CANOpen/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group CANOpen/inc/stm32
    ../CANOpen/inc/stm32/: applicfg.h canfestival.h timerscfg.h
  group MQTT
    ../MQTT/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Doc
    ../: Readme.txt
software components: CMSIS:CORE 5.0.1
